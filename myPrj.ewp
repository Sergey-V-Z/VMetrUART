# IAR project myPrj.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103RC ST STM32F103RC
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: STM32F103xE
  ICCARM.CCIncludePath2: CMSIS\Device\ST\STM32F1xx\Include; CMSIS\Include; Inc; Src; $PROJ_DIR$; FreeRTOS; FreeRTOS\inc; FreeRTOS\src
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.AUserIncludes: FreeRTOS
  OBJCOPY.OOCOutputFile: myPrj.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.IccLang: 1
  group (top)
    ./: startup_stm32f103xe.s system_stm32f1xx.c
  group CMSIS
    CMSIS/Include/: cmsis_compiler.h cmsis_version.h core_cm3.h
    CMSIS/Device/ST/STM32F1xx/Include/: stm32f103xe.h stm32f1xx.h system_stm32f1xx.h
  group FreeRTOS
    FreeRTOS/src/: croutine.c event_groups.c heap_2.c list.c port.c queue.c stream_buffer.c tasks.c timers.c
    FreeRTOS/: portasm.s
  group inc
    Inc/: ADC.hpp HID.hpp main.h USART.hpp
  group User
    Src/: ADC.cpp HID.cpp USART.cpp
    FreeRTOS/: FreeRTOSConfig.h stm32f10x_it.c
    ./: main.cpp
